FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://rtosamp_config.cfg"
